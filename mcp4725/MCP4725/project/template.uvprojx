# Keil uVision project template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103VE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_HD, __FPU_PRESENT
  c include: ..\CMSIS;..\User;..\HeaderFiles;..\Implement;..\Protocol;..\Delay;..\System;..\Check;..\Peripheral;..\HardDriver;..\Library\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: gd32f10x_it.c main.c
  group Implement
    ../Implement/: Implement.c
  group Peripheral
    ../Peripheral/: myiic.c
  group HardDriver
    ../HardDriver/: MCP4725.c
  group Delay
    ../Delay/: Delay.c
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h
  group System
    ../System/: systick.c
  group CMSIS
    ../CMSIS/: system_gd32f10x.c
  group Library
    ../Library/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ../Startup/: startup_gd32f10x_md.s
  group Readme
    ../Readme/: Readme.txt
software components: Data Exchange:JSON:Jansson 2.7.0
